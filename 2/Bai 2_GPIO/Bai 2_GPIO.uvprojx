# Keil uVision project Bai 2_GPIO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(36000000) ELITTLE
  output: Bai 2_GPIO
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.0.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
    RTE/Device/STM32F101RC/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
